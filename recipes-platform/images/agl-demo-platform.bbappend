IMAGE_INSTALL_append = " download-binding"

# debug using afb-client-demo
#IMAGE_INSTALL_append = " libafbwsc-dev"
